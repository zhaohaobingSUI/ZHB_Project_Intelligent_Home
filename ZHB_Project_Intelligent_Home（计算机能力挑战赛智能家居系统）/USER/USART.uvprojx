# Keil uVision project USART.uvprojx, settings and files
target USART (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\SDIO;..\HARDWARE\W25QXX;..\HARDWARE\MALLOC;..\USMART;..\HARDWARE\VS10XX;..\FATFS\src\option;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\PICTURE;..\APP;..\HARDWARE\DHT11;..\HARDWARE\LSENS;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\LED;..\HARDWARE\Alarm;..\HARDWARE\RELAY;..\HARDWARE\DCMOTOR
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/VS10XX/: vs10xx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TOUCH/: touch.c ctiic.c ft5206.c GT911.c gt9147.c ott2001a.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/LSENS/: lsens.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Alarm/: beep.c infrared.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/DCMOTOR/: dcmotor.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_exti.c stm32f10x_dac.c stm32f10x_adc.c
  group README
    ../: README.TXT
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group APP
    ../APP/: Information.c GUI.c SettingFace.c
